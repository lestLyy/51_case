# Keil uVision project shiyan5.uvproj, settings and files
target 目标 1 (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: shiyan5 +hex
  c flags: Optimize=8 SizeSpeed=1
  c define: DEBUG_ENABLE_SEMIHOST
  asm define: DEBUG_ENABLE_SEMIHOST
  group 源组 1
    ./: STARTUP.A51 shiyan5.c
